Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2021-10-06T14:26:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 06 14:26:15 2021 * Host: DESKTOP-VBJR5O1 * Database: C:\Users\Gonzalo\AppData\Local\Temp\{81EE8843-4497-47EE-B050-A2F6D6FC4AC1}\ifc * Database version: 5507 * Database creation date: Wed Oct 06 14:26:12 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 06 14:26:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 06 14:26:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Surface:201025
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Dimensions - Projected Area: 29494.7 m2; Surface Area: 30249.5 m2
Other - Category: Topography; Cut: 0 m3; Fill: 0 m3; Net cut/fill: 0 m3
Phasing - Phase Created: New Construction

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Building Story: yes; Name: Nivel 1; Structural: no
Dimensions - Computation Height: 0 m
Constraints - Elevation: 0 m

# IfcBuildingElementProxy: VOLUMEN TEÓRICO, VOLUMEN TEÓRICO:VOLUMEN TEÓRICO:206653
In: Nivel 1
Type - Material: Default Form
Type - Identity Data - Type Name: VOLUMEN TEÓRICO
Type - Other - Category: Mass; Family Name: VOLUMEN TEÓRICO
Pset_BuildingElementProxyCommon - Reference: VOLUMEN TEÓRICO
Constraints - Elevation: 0 m; Moves With Nearby Elements: no
Dimensions - Area: 9740.36 m2; Gross Floor Area: 65665 m2; Gross Surface Area: 24485.4 m2; Gross Volume: 218739 m3; Volume: 218739 m3
Other - Family: VOLUMEN TEÓRICO: VOLUMEN TEÓRICO; Family and Type: VOLUMEN TEÓRICO: VOLUMEN TEÓRICO; Type: VOLUMEN TEÓRICO: VOLUMEN TEÓRICO; Type Id: VOLUMEN TEÓRICO: VOLUMEN TEÓRICO
Phasing - Phase Created: New Construction
