Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-10-06T14:34:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 06 14:34:22 2021 * Host: DESKTOP-VBJR5O1 * Database: C:\Users\Gonzalo\AppData\Local\Temp\{243EE7C0-690D-484D-9CAB-A236CBB515E7}\ifc * Database version: 5507 * Database creation date: Wed Oct 06 14:34:22 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 06 14:34:22 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 06 14:34:22 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Surface:344409
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
